Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2017-11-01T15:46:55
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.0.428.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Nov 01 15:46:55 2017 * Host: B3ROBRAWR3331 * Database: C:\Users\RVI\AppData\Local\Temp\{182D1A18-3C81-4577-A1E6-E80C9D2C83E9}\ifc * Database version: 5507 * Database creation date: Wed Nov 01 15:46:54 2017 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Nov 01 15:46:54 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Nov 01 15:46:54 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Design Option: Main Model; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcAirTerminal: GS+ 40 EC, VE_Air Heater_MEPcontent_Mark_GS+ 35-40_INT-EN:GS+ 40 EC:1329616
In: V00
Type - Material: Color RGB 193-193-194, Color RGB 000-000-255, Color RGB 060-060-060
Type - Dimensions - Drain Diameter: 40 mm; Gas Diameter: 19 mm; Height: 810 mm; Length: 875 mm; Use Nominal Diameter: yes; Width: 1004 mm
Type - Electrical - Voltage: 230 V
Type - Electrical - Loads - Power: 290 W
Type - Identity Data - Article Description: Gas-fired high performance air heater with axial modulating fan; Article Type: GS+ 40 EC; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Gas-fired high performance air heater with axial modulating fan; EMCS Version: 4.0; ETIM Article Class: EC011395; Family Version: 11.06; GTIN: 87193336250115; Manufacturer: Mark; Manufacturer Art. No.: 5062501; Manufacturer URL: http://www.markclimate.com/air-heating/gas-fired/natural-gas-garage-heater-gs/; MEPcontent Class: AIR_HEATER; Model: GS+ 40 EC; OmniClass Number: 23.75.70.17; OmniClass Title: Water Heated and Cooled Terminal Heating and Cooling Units; Product Line: Mark; Revit Version: 2018; Type Name: GS+ 40 EC; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Mechanical - Air Flow Rate: 1.25 m3/s; Heating Power: 407952; Nominal Flow Rate: 0 m3/s
Type - Other - Category: Mechanical Equipment; Family Name: VE_Air Heater_MEPcontent_Mark_GS+ 35-40_INT-EN; Horizontal Thread Offset: 89.5 mm; Thread Size: 10 mm
Type - Pset_AirTerminalTypeCommon - Reference: GS+ 40 EC
Pset_ManufacturerTypeInformation - Manufacturer: Mark
Constraints - Offset: 0 mm
Dimensions - Area: 10.3068 m2; Flue Gas Diameter: 80 mm; Supply Air Diameter: 80 mm; Volume: 3.11544 m3
Identity Data - Design Option: Main Model; Mark: 4
Mechanical - Drain Fixture Units: 0; System Classification: Supply Air,Undefined,Other,Power,Sanitary
Mechanical - Flow - Flue Gas Flow: 0 m3/s; Gas Flow: 0 m3/s; Supply Air Flow: 0 m3/s
Model Properties - Condensate Pump: no; Pendant Length: 500 mm; Suspension Console: no
Other - Back Clearance Safe: 230 mm; Drain Angle: 0 deg; Drain Offset: 854.5 mm; Drain Position: 165 mm; Family: VE_Air Heater_MEPcontent_Mark_GS+ 35-40_INT-EN: GS+ 40 EC; Family and Type: VE_Air Heater_MEPcontent_Mark_GS+ 35-40_INT-EN: GS+ 40 EC; Horizontal Offset Safe: 0 mm; Pendant Length Safe: 500 mm; Pendants Visible: yes; Pump Reference Line Length: 800 mm; Reference Line Length: 52.5 mm; Reference Line Offset: 327.5 mm; Type: VE_Air Heater_MEPcontent_Mark_GS+ 35-40_INT-EN: GS+ 40 EC; Type Id: VE_Air Heater_MEPcontent_Mark_GS+ 35-40_INT-EN: GS+ 40 EC; Vertical Offset: 500 mm
Phasing - Phase Created: 4. Plan over 10 jaar
Visibility - Back Clearance: 230 mm; Horizontal Offset: 805.5 mm; Show Service Space: no
